# IAR project sif_zim.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC3250 NXP LPC3250
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 8
  ICCARM.CCIncludePath2: ; board\; modules\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sif_zim.bin
  ILINK.IlinkOutputFile: sif_zim.out
  ILINK.IlinkIcfFile: config\LPC3000_iRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug SDRAM (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: config\LPC3000_xRAM.icf
configuration Release SDRAM bool from NAND (ARM, debug)
  as the first configuration, except:
  AARM.ADefines: BOOT_LEVEL_2
  ILINK.IlinkIcfFile: config\LPC3000_xRAM.icf
  group (top)
    ./: arm_init.c CommUtil.c deviceUtil.c FlashRom_MX25V.c FPGA_ICE.c Global.c i2c_func.c init.c lcd.c main.c qr.c removetrend.c spi_func.c Timer_func.c
  group Define
    defines/: json_dscr.h packet.h sif_zim_def.h type.h
  group Ethernet
    ethernet/: fat.c http.c httpParser.c httpUtil.c json.c socket.c sockutil.c util.c w5100.c
  group lpc32xx_lib
    lpc32xx_lib/src/: lpc32xx_clkpwr_driver.c
  group mac
    config/: LPC3000_xRAM.mac
  group MMU
    board/: arm926ej_cp15_drv.c ttbl.c
  group Modules
    modules/: drv_intc.c
  group Modules/memory
    memory/: sdram_common.c
  group StartUp
    board/: cstartup.s
  group StartUp/BOOT
    board/: nand_bootloader.c
  group StartUp/iRAM
    board/: iram_init.c
  group StartUp/iRAM/Utility
    Utility/: nandflash.c
